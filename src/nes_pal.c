#include <math.h>
#include <noftypes.h>
#include <bitmap.h>
#include <nes_pal.h>

#ifndef PI
#define PI 3.1415926535897932384626433832795
#endif
 
rgb_t shady_palette[] =
{
   {0x80,0x80,0x80}, {0x00,0x00,0xBB}, {0x37,0x00,0xBF}, {0x84,0x00,0xA6},
   {0xBB,0x00,0x6A}, {0xB7,0x00,0x1E}, {0xB3,0x00,0x00}, {0x91,0x26,0x00},
   {0x7B,0x2B,0x00}, {0x00,0x3E,0x00}, {0x00,0x48,0x0D}, {0x00,0x3C,0x22},
   {0x00,0x2F,0x66}, {0x00,0x00,0x00}, {0x05,0x05,0x05}, {0x05,0x05,0x05},

   {0xC8,0xC8,0xC8}, {0x00,0x59,0xFF}, {0x44,0x3C,0xFF}, {0xB7,0x33,0xCC},
   {0xFF,0x33,0xAA}, {0xFF,0x37,0x5E}, {0xFF,0x37,0x1A}, {0xD5,0x4B,0x00},
   {0xC4,0x62,0x00}, {0x3C,0x7B,0x00}, {0x1E,0x84,0x15}, {0x00,0x95,0x66},
   {0x00,0x84,0xC4}, {0x11,0x11,0x11}, {0x09,0x09,0x09}, {0x09,0x09,0x09},

   {0xFF,0xFF,0xFF}, {0x00,0x95,0xFF}, {0x6F,0x84,0xFF}, {0xD5,0x6F,0xFF},
   {0xFF,0x77,0xCC}, {0xFF,0x6F,0x99}, {0xFF,0x7B,0x59}, {0xFF,0x91,0x5F},
   {0xFF,0xA2,0x33}, {0xA6,0xBF,0x00}, {0x51,0xD9,0x6A}, {0x4D,0xD5,0xAE},
   {0x00,0xD9,0xFF}, {0x66,0x66,0x66}, {0x0D,0x0D,0x0D}, {0x0D,0x0D,0x0D},

   {0xFF,0xFF,0xFF}, {0x84,0xBF,0xFF}, {0xBB,0xBB,0xFF}, {0xD0,0xBB,0xFF},
   {0xFF,0xBF,0xEA}, {0xFF,0xBF,0xCC}, {0xFF,0xC4,0xB7}, {0xFF,0xCC,0xAE},
   {0xFF,0xD9,0xA2}, {0xCC,0xE1,0x99}, {0xAE,0xEE,0xB7}, {0xAA,0xF7,0xEE},
   {0xB3,0xEE,0xFF}, {0xDD,0xDD,0xDD}, {0x11,0x11,0x11}, {0x11,0x11,0x11}
};
 
rgb_t nes_palette[64];


static float hue = 334.0f;
static float tint = 0.4f;

#include <gui.h>

void pal_dechue(void)
{
   hue -= 0.5f;
   gui_sendmsg(GUI_GREEN, "hue: %.02f", hue);
   pal_generate();
}
void pal_inchue(void)
{
   hue += 0.5f;
   gui_sendmsg(GUI_GREEN, "hue: %.02f", hue);
   pal_generate();
}
void pal_dectint(void)
{
   tint -= 0.01f;
   gui_sendmsg(GUI_GREEN, "tint: %.02f", tint);
   pal_generate();
}
void pal_inctint(void)
{
   tint += 0.01f;
   gui_sendmsg(GUI_GREEN, "tint: %.02f", tint);
   pal_generate();
}

static const float brightness[4][4] = 
{
   { 0.50f, 0.75f, 1.00f, 1.00f },
   { 0.29f, 0.45f, 0.73f, 0.90f },
   { 0.00f, 0.24f, 0.47f, 0.77f },
   { 0.02f, 0.04f, 0.05f, 0.07f }
};

static const int col_angles[16] =
{
   0, 240, 210, 180, 150, 120, 90, 60, 30, 0, 330, 300, 270, 0, 0, 0
};

void pal_generate(void)
{
   int x, z;
   float s, y, theta;
   int r, g, b;

   for (x = 0; x < 4; x++)
   {
      for (z = 0; z < 16; z++)
      {
         switch (z)
         {
         case 0: 
            s = 0;
            y = brightness[0][x];
            break;

         case 13: 
            s = 0;
            y = brightness[2][x];
            break;

         case 14:
         case 15: 
            s = 0;
            y = brightness[3][x];
            
            break;

         default:
            s = tint;                  
            y = brightness[1][x];       
            break;
         }

         theta = (float) (PI * ((col_angles[z] + hue) / 180.0));

         r = (int) (256.0 * (y + s * sin(theta)));
         g = (int) (256.0 * (y - ((27 / 53.0) * s * sin(theta)) + ((10 / 53.0) * s * cos(theta))));
         b = (int) (256.0 * (y - (s * cos(theta))));

         if (r > 255)
            r = 255;
         else if (r < 0)
            r = 0;

         if (g > 255)
            g = 255;
         else if (g < 0)
            g = 0;

         if (b > 255)
            b = 255;
         else if (b < 0)
            b = 0;

         nes_palette[(x << 4) + z].r = r;
         nes_palette[(x << 4) + z].g = g;
         nes_palette[(x << 4) + z].b = b;
      }
   }   
}